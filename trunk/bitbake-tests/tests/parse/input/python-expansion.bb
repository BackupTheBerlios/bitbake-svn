DATE = "${@time.strftime('%Y%m%d',0)}"
