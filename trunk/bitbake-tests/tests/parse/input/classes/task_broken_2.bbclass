python do_make_foo() {
}

addtask make_foo before do_build after do_nonexistant
