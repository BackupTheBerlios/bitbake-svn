PN = "moo"

FILES_${PN} = "foo"
