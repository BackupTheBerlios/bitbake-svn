# Test varFlags of the module
FOO_VAR = "one value - plain"
export FOO = "foo with shell export"

def foo() {
    print "Foo Method"
}

do_moo() {
    echo "shell function
}


