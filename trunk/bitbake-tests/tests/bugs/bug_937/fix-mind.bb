# Sample bb file to be parsable

HOMEPAGE = "yeah"
