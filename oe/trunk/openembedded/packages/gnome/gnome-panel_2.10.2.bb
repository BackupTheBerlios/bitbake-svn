LICENSE		= ""
HOMEPAGE	= "http://www.gnome.org"
DESCRIPTION	= "Panel for the GNOME desktop project"

DEPENDS 	= "libgnome libgnomeui gconf intltool gtk+"

inherit gnome
