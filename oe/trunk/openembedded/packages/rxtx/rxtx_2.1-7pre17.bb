DESCRIPTION	= "Java stuff for access serial ports"
HOMEPAGE	= "http://www.rxtx.org"
LICENSE		= ""

SRC_URI		= "ftp://jarvi.dsl.frii.com/pub/rxtx/rxtx-${PV}.tar.gz"

inherit autotools
