LICENSE		= ""
HOMEPAGE	= "http://gforge.lug.fi.uba.ar/projects/freeprince"
DESCRIPTION	= "Prince of persia game"

DEPENDS 	= "virtual/libsdl"

PV		= "0.4+cvs-${CVSDATE}"
SRC_URI		= "cvs://anonymous@ycvs.lug.fi.uba.ar/cvsroot/freeprince;module=FP"

S		= "${WORKDIR}/FP/src"
 
